# Keil uVision project st7789.uvprojx, settings and files
target st7789 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: st7789 +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Core/Src/tasks;../lvgl;../lvgl/src;../lvgl/src/core;../lvgl/src/draw;../lvgl/src/extra;../lvgl/src/extra/widgets/menu;../lvgl/src/font;../lvgl/src/gpu;../lvgl/src/hal;../lvgl/src/misc;../lvgl/src/widgets;../lvgl/examples;../lvgl/examples/widgets;../lvgl/examples/scroll;../lvgl/demos;../LVGL_Custom/Font;../
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --info=stack
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../: lv_conf.h
    ../Core/Src/: main.c gpio.c freertos.c spi.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Freertos tasks
    ../Core/Src/tasks/: TFT.c TFT.h
  group AuxFunctions
    ../AuxFunctions/: char_strings.h compound_types.c compound_types.h PrintDebug.c PrintDebug.h lv_mem_man.c lv_mem_man.h printf.c printf.h misc.c misc.h char_strings.c
  group LVGL/core
    ../lvgl/src/core/: lv_disp.c lv_disp.h lv_event.c lv_event.h lv_group.c lv_group.h lv_indev.c lv_indev.h lv_indev_scroll.c lv_indev_scroll.h lv_obj.c lv_obj.h lv_obj_class.c lv_obj_class.h lv_obj_draw.c lv_obj_draw.h lv_obj_pos.c lv_obj_pos.h lv_obj_scroll.c lv_obj_scroll.h lv_obj_style.c lv_obj_style.h lv_obj_style_gen.c lv_obj_style_gen.h lv_obj_tree.c lv_obj_tree.h lv_refr.c lv_refr.h lv_theme.c lv_theme.h
  group LVGL/draw
    ../lvgl/src/draw/: lv_draw.h lv_draw_arc.c lv_draw_arc.h lv_draw_img.c lv_draw_img.h lv_draw_label.c lv_draw_label.h lv_draw_line.c lv_draw_line.h lv_draw_mask.c lv_draw_mask.h lv_draw_rect.c lv_draw_rect.h lv_draw_triangle.c lv_draw_triangle.h lv_img_buf.c lv_img_buf.h lv_img_cache.c lv_img_cache.h lv_img_decoder.c lv_img_decoder.h lv_draw.c lv_draw_layer.c lv_draw_transform.c lv_draw_layer.h lv_draw_transform.h
    ../lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_layer.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c lv_draw_sw_transform.c lv_draw_sw.h lv_draw_sw_blend.h lv_draw_sw_dither.h lv_draw_sw_gradient.h
  group LVGL/font
    ../lvgl/src/font/: lv_font.c lv_font.h lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_fmt_txt.h lv_font_loader.c lv_font_loader.h lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c lv_symbol_def.h
  group LVGL/hal
    ../lvgl/src/hal/: lv_hal.h lv_hal_disp.c lv_hal_disp.h lv_hal_indev.c lv_hal_indev.h lv_hal_tick.c lv_hal_tick.h
  group LVGL/misc
    ../lvgl/src/misc/: lv_anim.c lv_anim.h lv_area.c lv_area.h lv_assert.h lv_async.c lv_async.h lv_bidi.c lv_bidi.h lv_color.c lv_color.h lv_fs.c lv_fs.h lv_gc.c lv_gc.h lv_ll.c lv_ll.h lv_log.c lv_log.h lv_math.c lv_math.h lv_mem.c lv_mem.h lv_printf.c lv_printf.h lv_style.c lv_style.h lv_style_gen.c lv_style_gen.h lv_templ.c lv_templ.h lv_timer.c lv_timer.h lv_tlsf.c lv_tlsf.h lv_txt.c lv_txt.h lv_txt_ap.c lv_txt_ap.h lv_types.h lv_utils.c lv_utils.h
  group LVGL/widgets
    ../lvgl/src/widgets/: lv_textarea.h lv_table.h lv_switch.h lv_slider.h lv_roller.h lv_objx_templ.h lv_line.h lv_label.h lv_img.h lv_dropdown.h lv_checkbox.h lv_canvas.h lv_btnmatrix.h lv_btn.h lv_bar.h lv_arc.h lv_textarea.c lv_table.c lv_switch.c lv_slider.c lv_roller.c lv_objx_templ.c lv_line.c lv_label.c lv_img.c lv_dropdown.c lv_checkbox.c lv_canvas.c lv_btnmatrix.c lv_btn.c lv_bar.c lv_arc.c
  group LVGL/src
    ../lvgl/src/: lv_api_map.h lv_conf_internal.h lv_conf_kconfig.h lvgl.h
  group LVGL/extra
    ../lvgl/src/extra/: lv_extra.c lv_extra.h
  group LVGL/extra/layouts
    ../lvgl/src/extra/layouts/: lv_layouts.h
    ../lvgl/src/extra/layouts/flex/: lv_flex.c lv_flex.h
    ../lvgl/src/extra/layouts/grid/: lv_grid.c lv_grid.h
  group LVGL/extra/themes
    ../lvgl/src/extra/themes/: lv_themes.h
    ../lvgl/src/extra/themes/basic/: lv_theme_basic.c lv_theme_basic.h
    ../lvgl/src/extra/themes/default/: lv_theme_default.c lv_theme_default.h
    ../lvgl/src/extra/themes/mono/: lv_theme_mono.c lv_theme_mono.h
  group LVGL/extra/widgets
    ../lvgl/src/extra/widgets/: lv_widgets.h
    ../lvgl/src/extra/widgets/animimg/: lv_animimg.c lv_animimg.h
    ../lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar.h lv_calendar_header_arrow.c lv_calendar_header_arrow.h lv_calendar_header_dropdown.c lv_calendar_header_dropdown.h
    ../lvgl/src/extra/widgets/chart/: lv_chart.c lv_chart.h
    ../lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c lv_colorwheel.h
    ../lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c lv_imgbtn.h
    ../lvgl/src/extra/widgets/keyboard/: lv_keyboard.c lv_keyboard.h
    ../lvgl/src/extra/widgets/led/: lv_led.c lv_led.h
    ../lvgl/src/extra/widgets/list/: lv_list.c lv_list.h
    ../lvgl/src/extra/widgets/meter/: lv_meter.c lv_meter.h
    ../lvgl/src/extra/widgets/msgbox/: lv_msgbox.c lv_msgbox.h
    ../lvgl/src/extra/widgets/span/: lv_span.c lv_span.h
    ../lvgl/src/extra/widgets/spinbox/: lv_spinbox.c lv_spinbox.h
    ../lvgl/src/extra/widgets/spinner/: lv_spinner.c lv_spinner.h
    ../lvgl/src/extra/widgets/tabview/: lv_tabview.c lv_tabview.h
    ../lvgl/src/extra/widgets/tileview/: lv_tileview.c lv_tileview.h
    ../lvgl/src/extra/widgets/win/: lv_win.c lv_win.h
    ../lvgl/src/extra/widgets/menu/: lv_menu.c lv_menu.h
  group LVGL/examples
    ../lvgl/examples/: lv_examples.h
  group LVGL/examples/assets
    ../lvgl/examples/assets/: animimg001.c animimg002.c animimg003.c img_caret_down.c img_cogwheel_alpha16.c img_cogwheel_argb.c img_cogwheel_chroma_keyed.c img_cogwheel_indexed16.c img_cogwheel_rgb.c img_hand.c img_skew_strip.c img_star.c imgbtn_left.c imgbtn_mid.c imgbtn_right.c
  group LVGL/examples/layouts
    ../lvgl/examples/layouts/: lv_example_layout.h
    ../lvgl/examples/layouts/flex/: lv_example_flex_1.c lv_example_flex_2.c lv_example_flex_3.c lv_example_flex_4.c lv_example_flex_5.c lv_example_flex_6.c lv_example_flex.h
    ../lvgl/examples/layouts/grid/: lv_example_grid_1.c lv_example_grid_2.c lv_example_grid_3.c lv_example_grid_4.c lv_example_grid_5.c lv_example_grid_6.c lv_example_grid.h
  group LVGL/examples/scroll
    ../lvgl/examples/scroll/: lv_example_scroll_1.c lv_example_scroll_2.c lv_example_scroll_3.c lv_example_scroll_4.c lv_example_scroll_5.c lv_example_scroll_6.c lv_example_scroll.h
  group LVGL/examples/widgets
    ../lvgl/examples/widgets/: lv_example_widgets.h
  group LVGL/examples/widgets/chart
    ../lvgl/examples/widgets/chart/: lv_example_chart_1.c lv_example_chart_2.c lv_example_chart_3.c lv_example_chart_4.c lv_example_chart_5.c lv_example_chart_6.c lv_example_chart_7.c
  group LVGL/examples/widgets/slider
    ../lvgl/examples/widgets/slider/: lv_example_slider_1.c lv_example_slider_2.c lv_example_slider_3.c
  group LVGL/examples/widgets/keyboard
    ../lvgl/examples/widgets/keyboard/: lv_example_keyboard_1.c
  group LVGL/examples/widgets/list
    ../lvgl/examples/widgets/list/: lv_example_list_1.c
  group LVGL/examples/widgets/table
    ../lvgl/examples/widgets/table/: lv_example_table_1.c lv_example_table_2.c
  group LVGL/examples/widgets/tabview
    ../lvgl/examples/widgets/tabview/: lv_example_tabview_1.c lv_example_tabview_2.c
  group LVGL/examples/widgets/menu
    ../lvgl/examples/widgets/menu/: lv_example_menu_1.c lv_example_menu_2.c lv_example_menu_3.c lv_example_menu_4.c lv_example_menu_5.c
  group LVGL/examples/widgets/btnmatrix
    ../lvgl/examples/widgets/btnmatrix/: lv_example_btnmatrix_1.c lv_example_btnmatrix_2.c lv_example_btnmatrix_3.c
  group LVGL/examples/widgets/spinbox
    ../lvgl/examples/widgets/spinbox/: lv_example_spinbox_1.c
  group LVGL/examples/widgets/dropdown
    ../lvgl/examples/widgets/dropdown/: lv_example_dropdown_1.c lv_example_dropdown_2.c lv_example_dropdown_3.c
  group LVGL_Custom
    ../LVGL_Custom/: theme.c theme.h display_settings.c display_settings.h
  group LVGL_Custom/Font
    ../LVGL_Custom/Font/: Noto16.c NotoEmoji_Bold_definitions.h Font_Awesome_6_Free_Solid_900_definitions.h Noto72compressed.c
  group ST7789
    ../ST7789/: core.c core.h lv_driver.c lv_driver.h
software components: CMSIS:CORE 4.3.0
